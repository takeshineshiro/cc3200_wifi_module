<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Borad</name>
    <file>
      <name>$PROJ_DIR$\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board.h</name>
    </file>
  </group>
  <group>
    <name>Button Control</name>
    <file>
      <name>$PROJ_DIR$\ButtonControl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ButtonControl.h</name>
    </file>
  </group>
  <group>
    <name>Common</name>
    <file>
      <name>$PROJ_DIR$\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\i2c_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\i2c_if.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\uart_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\uart_if.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\udma_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\udma_if.h</name>
    </file>
  </group>
  <group>
    <name>Miscs</name>
    <file>
      <name>$PROJ_DIR$\FreeRTOS_Hook.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\startup.c</name>
    </file>
  </group>
  <group>
    <name>Motor Control</name>
    <file>
      <name>$PROJ_DIR$\MotorControl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MotorControl.h</name>
    </file>
  </group>
  <group>
    <name>ProbeConfiguration</name>
    <file>
      <name>$PROJ_DIR$\ProbeConf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ProbeConf.h</name>
    </file>
  </group>
  <group>
    <name>QueueManager</name>
    <file>
      <name>$PROJ_DIR$\QueueManager.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\QueueManager.h</name>
    </file>
  </group>
  <group>
    <name>Sample Control</name>
    <file>
      <name>$PROJ_DIR$\SampleControl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SampleControl.h</name>
    </file>
  </group>
  <group>
    <name>SocketConnection</name>
    <file>
      <name>$PROJ_DIR$\SocketConnection.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SocketConnection.h</name>
    </file>
  </group>
  <group>
    <name>WifiConnection</name>
    <file>
      <name>$PROJ_DIR$\WifiConnection.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\WifiConnection.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\cc3200.icf</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
</project>


