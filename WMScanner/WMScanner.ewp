# IAR project WMScanner.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: ..\driverlib; ..\inc; ..\oslib; ..\third_party\FreeRTOS\source; ..\third_party\FreeRTOS\source\include; ..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4; ..\simplelink; ..\simplelink\source; ..\simplelink\include; common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WMScanner.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: cc3200.icf
  ILINK.IlinkAdditionalLibs: ..\driverlib\ewarm\Release\Exe\driverlib.a; ..\oslib\ewarm\free_rtos\Exe\free_rtos.a; ..\simplelink\ewarm\OS\Exe\simplelink.a; ..\third_party\fatfs\ewarm\Exe\fatfs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: cc3200.icf main.c main.h
  group Borad
    ./: board.c board.h
  group Button Control
    ./: ButtonControl.c ButtonControl.h
  group Common
    common/: common.h i2c_if.c i2c_if.h uart_if.c uart_if.h udma_if.c udma_if.h
  group Miscs
    ./: FreeRTOS_Hook.c startup.c
  group Motor Control
    ./: MotorControl.c MotorControl.h
  group ProbeConfiguration
    ./: ProbeConf.c ProbeConf.h
  group QueueManager
    ./: QueueManager.c QueueManager.h
  group Sample Control
    ./: SampleControl.c SampleControl.h
  group SocketConnection
    ./: SocketConnection.c SocketConnection.h
  group WifiConnection
    ./: WifiConnection.c WifiConnection.h
